options:
  parameters:
    author: jacob
    generate_options: qt_gui
    id: interrupt_emitter_example
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.from_uint64(48000)
    period: '1000'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.from_uint64(2), pmt.from_double(0.5))
    period: '1000'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: timing_utils_add_usrp_tags_0
  id: timing_utils_add_usrp_tags
  parameters:
    freq: '0'
    rate: samp_rate
    tag_now: '0'
    tf: '0'
    ti: '1'
    type: c
  states: {}
- name: timing_utils_interrupt_emitter_0
  id: timing_utils_interrupt_emitter
  parameters:
    late_pdu_mode: 'False'
    loop_gain: '0.0001'
    rate: samp_rate
    type: c
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', timing_utils_add_usrp_tags_0, '0']
- [blocks_add_xx_0, '0', blocks_tag_debug_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, timing_utils_interrupt_emitter_0, set]
- [blocks_message_strobe_0_0, strobe, timing_utils_interrupt_emitter_0, set]
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', timing_utils_interrupt_emitter_0, '0']
- [timing_utils_add_usrp_tags_0, '0', blocks_add_xx_0, '0']
- [timing_utils_interrupt_emitter_0, trig, blocks_message_debug_0, print]

metadata:
  file_format: 1
